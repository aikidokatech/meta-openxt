PRINC = "1"

RDEPENDS_packagegroup-base-keyboard = "\
    console-tools \
    xenclient-console-keymaps"
