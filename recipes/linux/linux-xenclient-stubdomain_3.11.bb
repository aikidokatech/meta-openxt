DESCRIPTION = "Linux kernel XenClient stubdomain"
COMPATIBLE_MACHINE = "(openxt-stubdomain)"

require linux-xenclient-${PV}.inc
