PR = "openxt-01"

# We only want libkmod2 really...
EXTRA_OECONF = "--disable-tools --disable-manpages --disable-logging --without-bashcompletiondir"
