PR = "openxt-01"

FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"

SRC_URI += "file://remove_mtrr.patch"


