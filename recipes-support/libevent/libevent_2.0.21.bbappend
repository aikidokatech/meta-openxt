EXTRA_OECONF += " --enable-openssl"

LDFLAGS += "-lrt"
