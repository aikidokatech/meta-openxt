PR = "openxt-01"

DEPENDS += "libselinux"
EXTRA_OECONF += "--with-selinux"
