PR = "openxt-01"

DEPENDS += "util-linux"
