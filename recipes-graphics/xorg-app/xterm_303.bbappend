PR = "openxt-01"
EXTRA_OECONF += "--enable-wide-chars"


