PR = "openxt-01"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
