PR = "openxt-01"

RDEPENDS_${PN} += "python-textutils"
