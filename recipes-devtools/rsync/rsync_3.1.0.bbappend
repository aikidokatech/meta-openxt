PR = "openxt-01"
EXTRA_OECONF += "--enable-xattr-support"
