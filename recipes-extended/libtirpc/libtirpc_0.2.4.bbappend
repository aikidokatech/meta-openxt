FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
SRC_URI += "file://compile-static-with-fPIC.patch"
