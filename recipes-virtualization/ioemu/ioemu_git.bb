require ioemu.inc

SRCREV_source = "${AUTOREV}"
SRCREV_patchqueue = "${AUTOREV}"
