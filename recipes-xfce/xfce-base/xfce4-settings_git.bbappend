PR = "openxt-01"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://minimal-settings-helper.patch"
